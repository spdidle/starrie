# Repository spdidle/starrie

File README.md:

# starlight 4 stasis

This is my very first PCB board, that I made star shaped following the beginner projects page on [Stasis](https://stasis.hackclub.com/starter-projects). This project uses an NE555P timer chip in astable mode to generate a clock pulse, which drives a CD4017 decade counter to sequence 10 LEDs.

## KiCad design starrie-pcb/StarLight.kicad_pcb

Parts:
C1: C_Polarized; CP_Radial_D5.0mm_P2.00mm
C2: C; C_Disc_D7.5mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: LED; LED_D3.0mm
J1: Conn_01x02_Socket; PinHeader_1x02_P2.54mm_Vertical
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: R_Potentiometer; Potentiometer_Vishay_T93YA_Vertical
U1: NE555P; DIP-8_W7.62mm
U2: 4017; N16

Connections:
+5V: J1.1, R1.1, U1.4 (~RST), U1.8 (VCC), U2.16 (VDD)
GND: C1.2, C2.2, J1.2, R2.2, U1.1 (GND), U2.8 (VSS), U2.13 (CKEN), U2.15 (Reset)
unnamed: D1.2 (A), U2.11 (Q9)
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), R2.1
unnamed: D2.2 (A), U2.9 (Q8)
unnamed: D3.2 (A), U2.6 (Q7)
unnamed: D4.2 (A), U2.5 (Q6)
unnamed: D5.2 (A), U2.1 (Q5)
unnamed: D6.2 (A), U2.10 (Q4)
unnamed: D7.2 (A), U2.7 (Q3)
unnamed: D8.2 (A), U2.4 (Q2)
unnamed: D9.2 (A), U2.2 (Q1)
unnamed: D10.2 (A), U2.3 (Q0)
unnamed: C2.1, U1.5 (CONT)
unnamed: R1.2, RV1.1, RV1.2, U1.7 (DISCH)
OUT: U1.3 (OUT), U2.14 (CLK)
TR: C1.1, RV1.3, U1.2 (TRIG), U1.6 (THRES)

Board: 2 copper layers, 92.4 x 89.9 mm, 18 parts (0 on the bottom side), 17 nets.

## Commit log

2026-03-17 Rename CnP_16032026_201228.png to 3D_VIEW
2026-03-17 Revise README
2026-03-17 Rename 3D_VIEW to 3D_VIEW.jpg
2026-04-08 BRO.
    how about you tell me BEFORE I SOLDER EVERYTHING ONTO THE BOARD THAT I MADE A MISTAKE OHH MY DAYS BRO OH MY DAYS. GENUINELY. TS BOARD IS RAGEBAITING?? I CANT
2026-04-08 ok fine.
    generate gerber files ig... do i even want to repair the board.
2026-04-11 NEW GERBERS
    this better be right or im gonna lose it. this is my last time ordering the pcb if it fails this time too i will do unspeakable things
2026-04-22 MY BOARD WORKS
    check lapse buddy i am ecstatsic? ecstatic? esctatic/? liek im so happy rn my board lights up YAY yay yay 3 cheer for me yay
